# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\User;..\Library\inc;..\Core;..\Hardware\LED;..\Hardware\KEY;..\Hardware\Delay;..\Hardware\USART;..\Hardware\ADC;..\Hardware\PWM;..\Hardware\BEEP;..\Hardware\MATRIX_KEY;..\Hardware\DHT11;..\Hardware\MQ2;..\Hardware\HCSR04;..\Hardware\SERVO;..\Hardware\OLED;..\Hardware\ESP8266;..\Hardware\APP;..\Hardware\ML;..\Hardware\RTC;..\Hardware\ML;..\Hardware\WDG;..\Hardware\CONFIG_STORE;..\Hardware\ESP32_CAM;..\Hardware\IIC;..\Hardware\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../Core/: startup_stm32f40_41xxx.s
  group user
    ./: stm32f4xx_it.c system_stm32f4xx.c main.c
  group library
    ../Library/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_tim.c misc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_pwr.c stm32f4xx_rtc.c
    ../../02示例工程/01工程搭建/02Template/Library/src/: stm32f4xx_crc.c stm32f4xx_flash.c stm32f4xx_iwdg.c
  group hardware
    ../Hardware/LED/: led.c led.h
    ../Hardware/KEY/: key.c key.h
    ../Hardware/Delay/: delay.c delay.h
    ../Hardware/USART/: usart.c usart.h
    ../Hardware/ADC/: adc.c adc.h
    ../Hardware/PWM/: pwm.c pwm.h
    ../Hardware/BEEP/: beep.c beep.h
    ../Hardware/MATRIX_KEY/: matrix_key.c matrix_key.h
    ../Hardware/DHT11/: dht11.c dht11.h
    ../Hardware/MQ2/: mq2.c mq2.h
    ../Hardware/HCSR04/: hcsr04.c hcsr04.h
    ../Hardware/SERVO/: servo.c servo.h
    ../Hardware/OLED/: oled.c oled.h
    ../Hardware/ESP8266/: esp8266.c esp8266.h
    ../Hardware/APP/: sensor_hub.c sensor_hub.h decision_engine.c decision_engine.h adaptive_threshold.c adaptive_threshold.h
    ../Hardware/WDG/: iwdg.c iwdg.h
    ../Hardware/CONFIG_STORE/: config_store.c config_store.h
    ../Hardware/ESP32_CAM/: esp32_cam.c esp32_cam.h
    ../Hardware/RTC/: rtc.c rtc.h
  group IIC
    ../Hardware/IIC/: iic.c iic.h
  group MPU6050
    ../Hardware/MPU6050/: mpu6050.c mpu6050.h
